# Keil uVision project Fatfs_SD.uvproj, settings and files
target Fatfs_SD (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Fatfs_SD +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\..\..\Library\Core;..\..\..\Library\Common;..\..\..\Library\STM32F10x_Lib\src;..\..\..\Library\STM32F10x_Lib\inc;..\..\..\Library\Common\Delay;..\..\..\Library\Common\System;..\..\..\Library\Hardware\USART;..\..\..\Library\Hardware\SPI;..\..\..\Library\Hardware\GPIO;..\..\..\Library\Hardware\SD;..\User\Fatfs_10b;..\User\Fatfs_10b\option
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../../../Library/Core/: core_cm3.c startup_stm32f10x_md.s
  group Common
    ../../../Library/Common/: system_stm32f10x.c
    ../../../Library/Common/Delay/: delay.c
    ../../../Library/Common/System/: system.c
  group Hareware
    ../../../Library/Hardware/USART/: usart.c usart.h
    ../../../Library/Hardware/SPI/: spi_hw.c spi_hw.h
    ../../../Library/Hardware/GPIO/: gpio.c gpio.h
    ../../../Library/Hardware/SD/: SD.c SD.h
  group User
    ../User/: main.c
  group Stm32_lib
    ../../../Library/STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Fatfs1.0
    ../User/Fatfs_10b/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
