# Keil uVision project USB_Mass_Storage.uvproj, settings and files
target USB_Mass_Storage (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_Mass_Storage +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL
  c include: ..\User;..\..\..\Library\Core;..\..\..\Library\Common;..\..\..\Library\STM32F10x_Lib\src;..\..\..\Library\STM32F10x_Lib\inc;..\..\..\Library\Common\System;..\..\..\Library\Hardware\GPIO;..\..\..\Library\Common\Delay;..\STM32_USB_USER\src;..\STM32_USB_USER\inc;..\STM32_USB-FS-Device_Driver\inc;..\STM32_USB-FS-Device_Driver\src;..\..\..\Library\Hardware\SD;..\..\..\Library\Hardware\SPI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../../../Library/Core/: core_cm3.c startup_stm32f10x_md.s
  group Common
    ../../../Library/Common/: system_stm32f10x.c
    ../../../Library/Common/System/: system.c
    ../../../Library/Common/Delay/: delay.c delay.h
  group Hareware
    ../../../Library/Hardware/GPIO/: gpio.c gpio.h
    ../../../Library/Hardware/SPI/: spi_hw.c
    ../../../Library/Hardware/SD/: SD.c
  group User
    ../User/: main.c
  group Stm32_lib
    ../../../Library/STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_USB_LIB
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32_USB_USER
    ../STM32_USB_USER/src/: hw_config.c mass_mal.c memory.c scsi_data.c stm32_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
