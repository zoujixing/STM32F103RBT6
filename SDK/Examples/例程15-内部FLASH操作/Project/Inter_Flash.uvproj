# Keil uVision project Inter_Flash.uvproj, settings and files
target Inter_Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Inter_Flash +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\..\..\Library\Core;..\..\..\Library\Common;..\..\..\Library\STM32F10x_Lib\src;..\..\..\Library\STM32F10x_Lib\inc;..\..\..\Library\Common\System;..\..\..\Library\Hardware\GPIO;..\..\..\Library\Hardware\USART;..\..\..\Library\Common\Delay;..\..\..\Library\Hardware\TFTLCD;..\..\..\Library\Hardware\STM32_FLASH
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../../../Library/Core/: core_cm3.c startup_stm32f10x_md.s
  group Common
    ../../../Library/Common/: system_stm32f10x.c
    ../../../Library/Common/System/: system.c system.h
    ../../../Library/Common/Delay/: delay.c delay.h
  group Hareware
    ../../../Library/Hardware/GPIO/: gpio.c gpio.h
    ../../../Library/Hardware/USART/: usart.c usart.h
    ../../../Library/Hardware/TFTLCD/: TFTLCD.c TFTLCD.h FONT.H
    ../../../Library/Hardware/STM32_FLASH/: flash.c flash.h
  group User
    ../User/: main.c
  group Stm32_lib
    ../../../Library/STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
